/* epd_gray.c - see epd_gray.h (bit mapping and LUTs from bb_epaper a9863c9, GPL-3.0).
 * SPDX-License-Identifier: GPL-3.0-or-later */
#include "epd_gray.h"

#include <string.h>

void epd_gray_planes(const uint8_t *src, size_t px, uint8_t *dtm1, uint8_t *dtm2)
{
    for (size_t o = 0; o < px / 8; o++) {
        /* 8 pixels = 2 source bytes; inverted gray i = 3 - g: DTM1 = bit 1 of i, DTM2 = bit 0 */
        uint16_t v = (uint16_t)(~((src[2 * o] << 8) | src[2 * o + 1]) & 0xffff);
        uint8_t hi = 0, lo = 0;
        for (int k = 0; k < 8; k++) {
            unsigned p = (v >> (14 - 2 * k)) & 3;
            hi = (uint8_t)(hi << 1 | (p >> 1));
            lo = (uint8_t)(lo << 1 | (p & 1));
        }
        if (dtm1)
            dtm1[o] = hi;
        if (dtm2)
            dtm2[o] = lo;
    }
}

/* bb_epaper epd75_old_gray_init, LUT 0x20..0x25, 4 groups each (rest of the 42 bytes zero) */
static const uint8_t GRAY_LUT[EPD_LUT_N][24] = {
    {0x00, 0x0A, 0x00, 0x00, 0x00, 0x01, 0x00, 0x14, 0x14, 0x0a, 0x00, 0x01,
     0x00, 0x19, 0x0f, 0x00, 0x00, 0x01, 0x00, 0x20, 0x01, 0x00, 0x00, 0x01},
    {0x40, 0x0A, 0x00, 0x00, 0x00, 0x01, 0x90, 0x14, 0x14, 0x0a, 0x00, 0x01,
     0x20, 0x14, 0x0A, 0x0a, 0x00, 0x01, 0xA0, 0x13, 0x0A, 0x04, 0x00, 0x01},
    {0x40, 0x0A, 0x00, 0x00, 0x00, 0x01, 0x90, 0x19, 0x19, 0x00, 0x00, 0x01,
     0x10, 0x19, 0x0F, 0x00, 0x00, 0x01, 0x99, 0x11, 0x04, 0x06, 0x06, 0x01},
    {0x40, 0x0A, 0x00, 0x00, 0x00, 0x01, 0x90, 0x19, 0x19, 0x00, 0x00, 0x01,
     0x10, 0x19, 0x0F, 0x00, 0x00, 0x01, 0x99, 0x10, 0x06, 0x08, 0x03, 0x01},
    {0x40, 0x0A, 0x00, 0x00, 0x00, 0x01, 0x00, 0x12, 0x12, 0x0e, 0x00, 0x01,
     0x40, 0x12, 0x16, 0x00, 0x00, 0x01, 0x50, 0x23, 0x01, 0x00, 0x00, 0x01},
    {0x40, 0x0A, 0x00, 0x00, 0x00, 0x01, 0x90, 0x14, 0x14, 0x00, 0x00, 0x01,
     0x10, 0x14, 0x0A, 0x00, 0x00, 0x01, 0xA0, 0x13, 0x0A, 0x00, 0x00, 0x01},
};

void epd_gray_luts(uint8_t out[EPD_LUT_N][EPD_LUT_LEN])
{
    for (int i = 0; i < EPD_LUT_N; i++) {
        memset(out[i], 0, EPD_LUT_LEN);
        memcpy(out[i], GRAY_LUT[i], sizeof GRAY_LUT[i]);
    }
}
